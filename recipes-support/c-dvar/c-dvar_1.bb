require ${PN}.inc

SRC_URI = "https://github.com/c-util/c-dvar/archive/v${PV}.tar.gz"
SRC_URI[md5sum] = "dd001aef84e74cf56f003167421fc159"
SRC_URI[sha256sum] = "6c549d96ea4d13f45712b4f0cfeff6ee17f2add064b24c352081f5bafbc6b053"
