require ${PN}.inc

SRC_URI = "https://github.com/c-util/c-rbtree/archive/v${PV}.tar.gz"
SRC_URI[md5sum] = "1a61dd960e4593da6fac3d792a9166a6"
SRC_URI[sha256sum] = "2a046005903c0a1d0e41069e4ce349e9a04acc977a564d90fcdba52ce9c9b67d"
