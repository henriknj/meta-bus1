require ${PN}.inc

SRC_URI = "https://github.com/c-util/c-list/archive/v${PV}.tar.gz"
SRC_URI[md5sum] = "1c49576fdd7c56c65ddad20226a30411"
SRC_URI[sha256sum] = "09b72f38599d1b78aa7b5a6fe93dfaf2d8e9128d8cf26748815bd5b539cb652d"
