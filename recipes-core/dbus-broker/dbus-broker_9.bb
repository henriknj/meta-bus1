require ${PN}.inc

SRC_URI = "https://github.com/bus1/dbus-broker/releases/download/v${PV}/dbus-broker-${PV}.tar.xz"
SRC_URI[md5sum] = "46ff06202e903e02b745e46115868c0b"
SRC_URI[sha256sum] = "f1ef696e751d4d09fc5729b8ef3ce0d3c12c333136ab50f4f8c52bde48eb06e8"
